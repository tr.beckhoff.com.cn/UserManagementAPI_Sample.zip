PROGRAM MAIN
VAR
	bIsMusketeer : BOOL := FALSE;
END_VAR

END_PROGRAM
